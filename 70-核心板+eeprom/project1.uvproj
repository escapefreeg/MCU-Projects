# Keil uVision project project1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD12864.c LCD12864.h Delay.c Delay.h AT24C02.c AT24C02.h I2C.c I2C.h
